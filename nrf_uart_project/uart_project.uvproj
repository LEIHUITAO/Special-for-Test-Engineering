# Keil uVision project uart_project.uvproj, settings and files
target NRF52832_XXAA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: uart_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52832_XXAA
  c include: .\modules\nrfx\templates;.\modules\nrfx\templates\nRF52832;.\modules\nrfx\mdk;.\modules\nrfx\hal;.\modules\nrfx\drivers;.\components\toolchain\cmsis\include;.\include;.\modules\nrfx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
  group user
    ./user/: main.c
  group source
    ./source/: led.c
